# i2s-mmap was removed in 4.9
KERNEL_DEVICETREE_append = " overlays/i2s-mmap.dtbo"
