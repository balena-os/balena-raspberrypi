CONNECTIVITY_FIRMWARES_append_raspberrypi3 = " linux-firmware-bcm43430"
