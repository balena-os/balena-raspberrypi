
PACKAGE_INSTALL += " \
	initramfs-module-usbflasher \
	kernel-module-dwc2 \
	kernel-module-g-mass-storage \
	"
