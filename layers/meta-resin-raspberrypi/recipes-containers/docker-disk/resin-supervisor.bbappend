LED_FILE_rpi = "/sys/class/leds/led0/brightness"
