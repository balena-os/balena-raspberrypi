# We override the file provided by meta-raspberrypi
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
