EXTRA_OEMAKE:append = " NO_LIBTRACEEVENT=1"
