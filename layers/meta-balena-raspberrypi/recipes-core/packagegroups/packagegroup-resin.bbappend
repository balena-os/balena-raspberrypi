RDEPENDS_${PN} += "udev-rules-rpi \
    u-blox-modeswitch \
"
