do_install[nostamp] = "1"
do_deploy[nostamp] = "1"
do_configure[nostamp] = "1"
do_package[nostamp] = "1"
