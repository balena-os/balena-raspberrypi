TTYS:append:iotg-rpi5 = " ttyAMA0"
