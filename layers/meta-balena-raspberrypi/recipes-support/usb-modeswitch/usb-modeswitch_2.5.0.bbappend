FILESEXTRAPATHS_append := ":${THISDIR}/files"

SRC_URI += "file://usb_modeswitch_avoid_coredump.patch"
