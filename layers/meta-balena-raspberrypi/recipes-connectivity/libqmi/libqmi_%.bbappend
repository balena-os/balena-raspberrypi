SRCREV = "08e92a0ab670711cd1d2ad4da8b676c4ba08a7fe"
SRC_URI = "git://gitlab.freedesktop.org/mobile-broadband/libqmi.git;protocol=https;branch=main"
