SRCREV = "38ceec55fc84ff5412b6ae920825a8c6c96dde38"
SRC_URI = "git://gitlab.freedesktop.org/mobile-broadband/libmbim.git;protocol=https;branch=main"
