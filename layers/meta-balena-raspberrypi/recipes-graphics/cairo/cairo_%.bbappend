PACKAGECONFIG:remove = " egl glesv2"
